RENESAS_BSP_URL = "git://github.com/otyshchenko1/linux.git"

BRANCH = "v5.10/rcar-5.0.0.rc4-xt0.1"
SRCREV = "${AUTOREV}"
LINUX_VERSION = "5.10.0"
