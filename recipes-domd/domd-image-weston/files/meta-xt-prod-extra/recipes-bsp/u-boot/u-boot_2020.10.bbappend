FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0003-Fix-missing-MACCTLR-register-setting-in-initializati.patch \
"